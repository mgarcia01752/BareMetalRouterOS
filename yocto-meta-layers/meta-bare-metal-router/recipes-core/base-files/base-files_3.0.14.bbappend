SUMMARY = "Append base-files"
DESCRIPTION = "Customizing base-files for bare-metal-router setting"
LICENSE = "MIT"

# Overwrite hostname
hostname = "Router"